# Keil uVision project BasicCourse.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: BasicCourse +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\INC
  group INC
    ../INC/: STC51.h Delay.h LED.h KEY.h BEEP.h NixieTube.h Time.h usart.h Lcd1602.h Ds18b20.h
  group SRC
    ../SRC/: main.c
  group CODE
    ../CODE/: Delay.c LED.c KEY.c BBBP.c NixieTube.c Time.c usart.c Lcd1602.c Ds18b200.c
  group APP
    ../APP/: LedApp.c
