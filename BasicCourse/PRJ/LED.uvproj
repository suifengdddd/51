# Keil uVision project LED.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: LED +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\INC
  group Source Group 1
    ./: STARTUP.A51
  group INC
    ../INC/: Delay.h LED.h STC51.h KEY.h BEEP.h NixieTube.h Time.h usart.h Lcd1602.h Ds18b20.h
  group SRC
    ../SRC/: main.c
  group CODE
    ../CODE/: Delay.c LED.c KEY.c BBBP.c NixieTube.c Time.c usart.c Lcd1602.c Ds18b200.c
  group APP
    ../APP/: LedApp.c
